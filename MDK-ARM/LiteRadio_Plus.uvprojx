# Keil uVision project LiteRadio_Plus.uvprojx, settings and files
target LiteRadio_Plus (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LiteRadio_Plus +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,LiteRadio_Plus_CC2500
  c include: ../Inc;                                 ../Drivers/STM32F1xx_HAL_Driver/Inc;                                 ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;                                 ../Middlewares/Third_Party/FreeRTOS/Source/include;                                 ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;                                 ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;                                 ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;                                 ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;                                 ../Drivers/CMSIS/Include;                                 ..\USER\Drivers;                                 ..\USER\Hardware;                                 ../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Inc;                                 ..\USER\protocol;                                 ..\USER\systemview\Config;                                 ..\USER\systemview\FreeRTOSV10\Config\Cortex-M;                                 ..\USER\systemview\FreeRTOSV10\Config;                                 ..\USER\systemview\FreeRTOSV10\Patch;                                 ..\USER\systemview\FreeRTOSV10;                                 ..\USER\systemview\SEGGER\Syscalls;                                 ..\USER\systemview\SEGGER
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Src/: main.c gpio.c freertos.c adc.c dma.c iwdg.c spi.c tim.c usart.c usb_device.c usbd_conf.c usbd_desc.c usbd_custom_hid_if.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_ll_usb.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Src/: usbd_customhid.c
  group Drivers
    ../USER/Drivers/: stmflash.c joystick.c mixes.c radiolink.c function.c status.c tx_main.c
  group Hardware
    ../USER/Hardware/: gimbal.c switches.c buzzer.c key.c cc2500.c rgb.c sx1280.c sx1280hal.c
    ../USER/Drivers/: delay.c
  group Protocol
    ../USER/protocol/: frsky_d16.c frsky_d8.c s_fhss.c crsf.c fhss.c common.c elrs_v3.c
    ../USER/Drivers/: pc_control.c usb_pc.c
target LiteRadio_Plus_SX1280 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: LiteRadio_Plus +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,LiteRadio_Plus_SX1280,TARGET_TX_BETAFPV_2400_V1,Regulatory_Domain_ISM_2400
  c include: ../Inc;                        ../Drivers/STM32F1xx_HAL_Driver/Inc;                        ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;                        ../Middlewares/Third_Party/FreeRTOS/Source/include;                        ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;                        ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;                        ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;                        ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;                        ../Drivers/CMSIS/Include;                        ..\USER\Drivers;                        ..\USER\Hardware;                        ../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Inc;                        ..\USER\protocol;                        ..\USER\systemview\Config;                        ..\USER\systemview\FreeRTOSV10\Config\Cortex-M;                        ..\USER\systemview\FreeRTOSV10\Config;                        ..\USER\systemview\FreeRTOSV10\Patch;                        ..\USER\systemview\FreeRTOSV10;                        ..\USER\systemview\SEGGER\Syscalls;                        ..\USER\systemview\SEGGER
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x18000
  memory RVCT9: RAM 0x20000000 size 0x5000
target LiteRadio_Plus_CC2500 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: LiteRadio_Plus +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,LiteRadio_Plus_CC2500
  c include: ../Inc;                         ../Drivers/STM32F1xx_HAL_Driver/Inc;                         ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;                         ../Middlewares/Third_Party/FreeRTOS/Source/include;                         ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;                         ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;                         ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;                         ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;                         ../Drivers/CMSIS/Include;                         ..\USER\Drivers;                         ..\USER\Hardware;                         ../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Inc;                         ..\USER\protocol;                         ..\USER\systemview\Config;                         ..\USER\systemview\FreeRTOSV10\Config\Cortex-M;                         ..\USER\systemview\FreeRTOSV10\Config;                         ..\USER\systemview\FreeRTOSV10\Patch;                         ..\USER\systemview\FreeRTOSV10;                         ..\USER\systemview\SEGGER\Syscalls;                         ..\USER\systemview\SEGGER
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 4.3.0
